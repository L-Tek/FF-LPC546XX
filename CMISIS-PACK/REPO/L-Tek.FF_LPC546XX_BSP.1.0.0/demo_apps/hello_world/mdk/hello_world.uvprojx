# Keil uVision project hello_world.uvprojx, settings and files
target hello_world debug (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../..;..
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  group source
    ../: hello_world.c
  group doc
    ../: readme.txt
target hello_world release (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: as above
  c include: ../../..;..
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
software components: Device:SDK Drivers:iocon 2.0.0, Device:SDK Drivers:clock 2.1.0, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Drivers:reset 2.0.0, Device:SDK Utilities:assert 1.0.0, CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:SDK Drivers:usart 2.0.1, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:gpio 2.1.1, Device:SDK Drivers:power 2.0.0, Device:Startup 1.0.0, Device:SDK Drivers:flexcomm 2.0.0, Device:SDK Drivers:emc 2.0.0
